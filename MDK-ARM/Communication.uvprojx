# Keil uVision project Communication.uvprojx, settings and files
target Communication (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F373CCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(72000000) FPU2 CPUTYPE("Cortex-M4")
  output: Communication +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F373xC
  c include: ../Core/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f373xc.s
  group Application/User
    ../Core/Src/: main.c gpio.c dac.c dma.c sdadc.c spi.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
software components: CMSIS:CORE 5.1.1
